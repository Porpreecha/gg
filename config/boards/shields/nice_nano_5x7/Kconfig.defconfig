## config/boards/shields/nice_nano_5x7/Kconfig.defconfig
```kconfig
if SHIELD_nice_nano_5x7

config ZMK_KEYBOARD_NAME
    default "nice_nano_5x7"

endif
```
